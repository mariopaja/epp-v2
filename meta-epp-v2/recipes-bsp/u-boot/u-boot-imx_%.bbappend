FILESEXTRAPATHS:prepend := "${THISDIR}/files:${THISDIR}/../epp-v2-overlays/files:"

SRC_URI += "file://epp-v2-no-efi-boot.cfg"

# Header pins U-Boot switches at boot (EPP_XEN_ZEPHYR_EARLY_PINS, board.conf):
# the pin groups of these passthrough devices (epp-zephyr-<name>-pins.dtsi of
# epp-v2-overlays) join U-Boot's pinctrl hog, set over SCMI before Xen starts
# the Zephyr DomU. For Zephyr drivers that access their device at boot,
# before Dom0 would set the pins.
SRC_URI += "${@' '.join('file://epp-zephyr-%s-pins.dtsi' % n for n in d.getVar('EPP_XEN_ZEPHYR_EARLY_PINS').split())}"
do_configure[vardeps] += "EPP_XEN_ZEPHYR_EARLY_PINS"

do_configure:prepend() {
    dtsi=${S}/arch/arm/dts/imx95-15x15-frdm-u-boot.dtsi
    sed -i '/epp-early-pins.dtsi/d' $dtsi
    if [ -n "${EPP_XEN_ZEPHYR_EARLY_PINS}" ]; then
        out=${S}/arch/arm/dts/epp-early-pins.dtsi
        groups=""
        for n in ${EPP_XEN_ZEPHYR_EARLY_PINS}; do groups="$groups &pinctrl_epp_$n"; done
        printf '/* Generated by u-boot-imx_%%.bbappend (epp-v2): EPP_XEN_ZEPHYR_EARLY_PINS */\n&scmi_iomuxc {\n\tpinctrl-0 = <&pinctrl_hog%s>;\n\n' "$groups" > $out
        for n in ${EPP_XEN_ZEPHYR_EARLY_PINS}; do cat ${UNPACKDIR}/epp-zephyr-$n-pins.dtsi >> $out; done
        printf '};\n' >> $out
        echo '#include "epp-early-pins.dtsi"' >> $dtsi
    fi
}
